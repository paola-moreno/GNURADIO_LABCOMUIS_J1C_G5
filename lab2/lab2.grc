options:
  parameters:
    author: labcom
    generate_options: qt_gui
    id: lab2
    output_language: python
    title: conexion SDR
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    label: amplitud señal tx
    start: '0'
    step: '100E-6'
    stop: '1'
    value: '1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: ganancia del GTX
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: frecuencia portadora
    start: 50E6
    step: 1E6
    stop: 2.2E9
    value: '50000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: A
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
